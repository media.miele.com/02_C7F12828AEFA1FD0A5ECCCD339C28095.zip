Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: ebbe6537-9ac4-4444-a042-f0ff6bd1c0e6, NumberOfSaves: 1]
File name: 0001
Time: 2025-09-19T07:52:35+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11843380_SOM_PDR514ROPEL_IG:52514011_SOM_11843380_PDR514ROPEL_IG, (2)
In: Default
Type - Material: z_Miele_Connection_Electric, z_Miele_Design_Stainless_Steel, z_Miele_Design_Glass Black, z_Miele_Design_Iron_Grey, z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, Rubber, Black, z_Miele_Design_Glass, z_Miele_Connection_Gas, <Unnamed>, z_Miele_Connection_ExhaustAir
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 52514011_SOM_11843380_PDR514ROPEL_IG; sets with these values: 2

# IfcDistributionPort, Port_355454_1
Description: Flow; FlowDirection: SOURCEANDSINK
